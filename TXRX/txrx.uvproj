# Keil uVision project txrx.uvproj, settings and files
target TXRX (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: txrx +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\compiler\c51;..\compiler\common;..\hal;..\hal\nrf24le1;..\hal\nrf24l01p;..
  group app
    ./: main.c esb_app_txrx_noack.c
  group hal
    ../hal/nrf24le1/: hal_clk.c hal_nrf_hw.c hal_uart.c hal_wdog.c
    ../hal/: hal_delay.c
    ../hal/nrf24l01p/: hal_nrf.c
