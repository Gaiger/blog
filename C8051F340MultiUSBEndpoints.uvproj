# Keil uVision project C8051F340MultiUSBEndpoints.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: BloggerMultiEndpoint
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 F3xx_USB0_Descriptor.c F3xx_USB0_InterruptServiceRoutine.c F3xx_USB0_Main.c F3xx_USB0_ReportHandler.c F3xx_USB0_Standard_Requests.c F340_USB0_Mouse.c
