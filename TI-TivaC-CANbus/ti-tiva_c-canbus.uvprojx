# Keil uVision project ti-tiva_c-canbus.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ti-tiva_c-canbus
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA0
  c include: TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ./: main.c startup_rvmdk.S Retarget.c
  group Lib
    TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
