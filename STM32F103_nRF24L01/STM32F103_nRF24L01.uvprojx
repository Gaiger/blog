# Keil uVision project STM32F103_nRF24L01.uvprojx, settings and files
target App (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gaiger_practice
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\STM32F10x_StdPeriph_Lib_V3.5.0\inc;.\core;.\;.\nRF24L01_hal;.\nRF24L01_hal\nrf24l01p;.\nRF24L01_hal\stm32F103
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ./: main.c esb_app.c
  group core
    ./core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ./STM32F10x_StdPeriph_Lib_V3.5.0/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group nRF24L01_hal
    ./nRF24L01_hal/stm32F103/: hal_nrf_hw.c
    ./nRF24L01_hal/nrf24l01p/: hal_nrf.c
software components: CMSIS:CORE 4.3.0
